options:
  parameters:
    author: KIIT
    generate_options: qt_gui
    id: audio_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 0, 1, 1
    labels: noaa_stations_labels
    num_opts: '0'
    options: '[f[0] for f in noaa_stations]'
    type: real
    value: noaa_stations[0][0]
  states: {}
- name: noaa_stations
  id: variable
  parameters:
    value: '[(137.62e6, ''NOAA-15''),(137.9125e6, ''NOAA-18''),(137.1e6, ''NOAA-19'')]'
  states: {}
- name: noaa_stations_labels
  id: variable
  parameters:
    value: '[''{:>7.3f} MHz (Channel {:3})''.format(f[0]/1e6, f[1]) for f in noaa_stations]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\KIIT\Desktop\Sea of tranquility\GNU radio\rf_rx.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '12'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
